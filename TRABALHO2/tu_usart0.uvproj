# Keil uVision project tu_usart0.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: tu_usart0 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: config_platform.c serialIO.c state_machine.c timer2_delay.c timer2_delay.h
