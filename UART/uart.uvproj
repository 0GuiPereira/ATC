# Keil uVision project uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: state_machine +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: init_device.c init_device.h uart.c config_platform.c serialIO.c tu_usart0.c
