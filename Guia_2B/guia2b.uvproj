# Keil uVision project guia2b.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB31F64G-QFN32 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xF9FF) CLOCK(49000000)
  output: guia2b +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c init.c init.h serialIO.c serialIO.h pca0.c pca0.h fsm.c fsm.h
