# Keil uVision project i2c-bitbang.uvproj, settings and files
target 8051F388 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: i2c-bitbang +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c types.h i2c-bitbang.c i2c-bitbang.h
