# Keil uVision project guia_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: guia_1 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: timer2_interrupt.c
