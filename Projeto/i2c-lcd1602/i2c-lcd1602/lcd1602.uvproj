# Keil uVision project lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: lcd1602 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c types.h i2c-bitbang.c i2c-bitbang.h lcd1602.c lcd1602.h
